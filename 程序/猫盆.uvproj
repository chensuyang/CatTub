# Keil uVision project 猫盆.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C55 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: 猫盆 +hex
  c flags: Optimize=2
  group Source Group 1
    ./: STARTUP.A51 main.c ds18b20.c tm1620.c EEPROM.c delay.c PTC.c buzzer.c button.c Heartbeat.c timer0.c
